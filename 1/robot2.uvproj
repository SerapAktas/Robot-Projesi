# Keil uVision project robot2.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: robot2
  c flags: Optim=1
  c include: ..\driver\driverlib;..\driver\driverlib\inc;..\driver\utils
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Startup.s
    ../robot/: sonrobot.c
  group inc
    ../driver/driverlib/inc/: asmdefs.h debug.h hw_adc.h hw_can.h hw_comp.h hw_eeprom.h hw_epi.h hw_ethernet.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_i2s.h hw_ints.h hw_lpc.h hw_memmap.h hw_nvic.h hw_peci.h hw_pwm.h hw_qei.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h lm4f120h5qr.h
    ../driver/utils/: uartstdio.h
  group fnc
    ../driver/driverlib/: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    ../driver/utils/: uartstdio.c
